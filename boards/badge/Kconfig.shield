## boards/shields/badge/Kconfig.defconfig
```kconfig
if SHIELD_BADGE

config ZMK_KEYBOARD_NAME
    default "Tues BADGE"
endif
CONFIG_ZMK_STUDIO=y
CONFIG_ZMK_KSCAN_DIRECT_POLLING=y
```
